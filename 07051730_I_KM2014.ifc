Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 46849186-51ec-4979-b754-f73b35b88f5b, NumberOfSaves: 1]
File name: 0001
Time: 2026-01-14T06:49:04+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 07051730_I_KM2014:26201450_I_7051730_KM2014, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_CLST, z_Miele_Design_Cast, z_Miele_Design_Zinc_Steel, z_Miele_Connection_Gas, z_Miele_Connection_Electric, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 650 mm; Height: 90 mm; Depth: 520 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 26201450_I_7051730_KM2014; sets with these values: 2

# IfcDistributionPort, Port_356775_1
Description: Flow; FlowDirection: SOURCEANDSINK
